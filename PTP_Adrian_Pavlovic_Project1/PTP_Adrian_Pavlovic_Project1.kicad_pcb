# Repository Adrox7/PTP_Adrian_Pavlovic_Project1

## KiCad design PTP_Adrian_Pavlovic_Project1/PTP_Adrian_Pavlovic_Project1.kicad_pcb

Parts:
C1: 22u; CP_Radial_D5.0mm_P2.00mm; Manufacturer Part Number EWH1EM220D11OT
C2: 220u; CP_Radial_D5.0mm_P2.00mm; Manufacturer Part Number RD1A227M05011BB
C3: 1u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Manufacturer Part Number CL31B105KBHNNNE
C4: 100n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Manufacturer Part Number CL31B104KBCNNNC
C5: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Manufacturer Part Number CL31A106KBHNNNE
D1, D2, D3, D5: LED; LED_D5.0mm
D4: 11DQ06; D_DO-41_SOD81_P12.70mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_5.5mm
J1: Screw_Terminal_01x02; TerminalBlock_MetzConnect_Type011_RT05502HBLC_1x02_P5.00mm_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
L1: 330u; L_Radial_D7.2mm_P3.00mm_Murata_1700
R1, R2, R3, R4: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6, R8, R13, R14, R16, R17, R18: 2k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R7, R9, R10, R11, R12: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R15: 10K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R19, R20: 47K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm_H4.3mm
SW2: SW_SPDT_312; SW_Slide_SPDT_Straight_CK_OS102011MS2Q
U1: LM2574N-5; DIP-8_W7.62mm_Socket_LongPads; Manufacture Part Number LM2574N-5G
U2, U3: 4027; DIP-16_W7.62mm_Socket_LongPads
U4: 74LS47; DIP-16_W7.62mm_Socket_LongPads
U5: HDSP-7401
U6: 74LVC1G11; SOT-23-6
U7: NE555P; DIP-8_W7.62mm

Connections:
555: SW2.2 (C), U7.3 (Q)
+5V: C2.1, C4.1, L1.2, R7.1, R9.1, R10.1, R11.1, R12.1, R15.1, R19.1, U1.1 (FB), U2.16 (VDD), U3.16 (VDD), U4.16 (VCC), U5.1 (CA), U5.6 (CA), U6.5 (VCC), U7.4 (R), U7.8 (VCC)
Clock: R7.2, SW2.1 (B), U2.3 (C), U6.6 (C)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, D4.2 (A), J1.1, R1.2, R2.2, R3.2, R4.2, SW1.1, U1.2 (SGND), U1.3 (~ON/OFF), U1.4 (PGND), U2.7 (S), U2.8 (VSS), U2.9 (S), U3.7 (S), U3.8 (VSS), U3.9 (S), U4.8 (GND), U6.2 (GND), U7.1 (GND)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: D4.1 (K), L1.1, U1.7 (OUT)
unnamed: D5.1 (K), R4.1
unnamed: R13.1, SW1.2
unnamed: C3.2, R13.2, SW2.3 (A)
unnamed: R9.2, U2.5 (K), U2.6 (J)
unnamed: R10.2, U2.10 (J), U2.11 (K)
unnamed: R11.2, U3.5 (K), U3.6 (J)
unnamed: R12.2, U3.10 (J), U3.11 (K)
unnamed: R15.2, U4.3 (LT), U4.4 (BI), U4.5 (RBI)
unnamed: R5.1, U4.13 (a)
unnamed: R6.1, U4.12 (b)
unnamed: R8.1, U4.11 (c)
unnamed: R14.1, U4.10 (d)
unnamed: R16.1, U4.9 (e)
unnamed: R17.1, U4.15 (f)
unnamed: R18.1, U4.14 (g)
unnamed: R5.2, U5.10 (A)
unnamed: R6.2, U5.9 (B)
unnamed: R8.2, U5.8 (C)
unnamed: R14.2, U5.5 (D)
unnamed: R16.2, U5.4 (E)
unnamed: R17.2, U5.2 (F)
unnamed: R18.2, U5.3 (G)
unnamed: R19.2, R20.1, U7.7 (DIS)
unnamed: C5.1, R20.2, U7.2 (TR), U7.6 (THR)
Q0: D1.2 (A), U2.1 (Q), U2.13 (C), U4.7 (A)
Q1: D2.2 (A), U2.15 (Q), U3.3 (C), U4.1 (B), U6.1 (A)
Q2: D3.2 (A), U3.1 (Q), U3.13 (C), U4.2 (C)
Q3: D5.2 (A), U3.15 (Q), U4.6 (D), U6.3 (B)
Reset: U2.4 (R), U2.12 (R), U3.4 (R), U3.12 (R), U6.4 (Y)
VD: C1.1, J1.2, U1.5 (VIN)

Notes on the sheet:
LCD Diode
Tipkala i ulaz radnog takta
Montažne rupe
Napajanje
JK Bistabil
Napajaje bistabila
555 timer
Reset Brojača

Board: 2 copper layers, 100.0 x 80.0 mm, 45 parts (0 on the bottom side), 38 nets.

## Commit log

2025-10-21 Ispunjena sastavnica
2025-10-28 LV2_rijesen
2025-11-11 project1
2025-11-25 Vjezba7
2026-01-20 Zadnja vježba
